## eddy_ng/Kconfig
```kconfig
config WANT_EDDY_NG
    bool "Include eddy_ng ldc1612 support"

config WANT_EDDY_NG_DEBUG
    bool "Enable verbose eddy_ng logging"
    depends on WANT_EDDY_NG
```
